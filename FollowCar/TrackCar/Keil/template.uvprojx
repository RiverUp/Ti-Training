# Keil uVision project template.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\Lib;..\Lib\CMSIS\include;..\RTthread\bsp;..\RTthread\include;..\User\Drivers;..\User\Threads
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group User
    ../User/: main.c
  group Driverlib
    ../Lib/ti/devices/msp432p4xx/driverlib/: adc14.c aes256.c comp_e.c cpu.c crc32.c cs.c dma.c flash.c flash_a.c fpu.c gpio.c i2c.c interrupt.c lcd_f.c mpu.c pcm.c pmap.c pss.c ref_a.c reset.c rtc_c.c spi.c sysctl.c sysctl_a.c systick.c timer_a.c timer32.c uart.c wdt_a.c
  group Lib
    ../Lib/ti/devices/msp432p4xx/startup_system_files/: system_msp432p401r.c
    ../Lib/ti/devices/msp432p4xx/startup_system_files/keil/: startup_msp432p401r_uvision.s
  group RTthread
    ../RTthread/bsp/: board.c
    ../RTthread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../RTthread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group Drivers
    ../User/Drivers/: Delay.c Encoder.c Filter.c HC-05.c HC-SR04.c Interrupt.c Motor.c oled.c Serial.c TCRT5000.c
  group Thread
    ../User/Threads/: control_entry.c display_entry.c
